<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ivan_Ljubisavljevic_115_2015_Domaci_2.ewp</path>
  </project>
  <batchBuild />
</workspace>
